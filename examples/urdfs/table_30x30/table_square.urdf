Commit message: correct table model

File: examples/urdfs/table_30x30/table_square.urdf (robot description, URDF)
Before this commit: robot urdf_table, 2 links, 1 joints
Links:
- link baseLink: geometry collision box size=0.6 0.6 0.08; visual box size=0.025 0.025 0.30
